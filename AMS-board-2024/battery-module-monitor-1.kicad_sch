File: AMS-board-2024/battery-module-monitor-1.kicad_sch (KiCad schematic)
At the start: 164 parts, among them Q1 BSS308PE, Q10 BSS308PE, Q11 BSS308PE, Q12 BSS308PE, Q13 NSV1C201MZ4, Q2 BSS308PE, Q3 BSS308PE, Q4 BSS308PE, Q5 BSS308PE, Q6 BSS308PE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

Commit message: ERC実行、修正
ラベル修正、未配線部分修正、PWR_FLAG追加
Connections:
- net GND1: now also U1.36 (SWTEN)
- net VREG renamed VREG1
