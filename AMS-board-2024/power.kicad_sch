File: AMS-board-2024/power.kicad_sch (KiCad schematic)
At the start: 61 parts, among them Q109 DMT6007LFGQ, Q110 BSS308PE, Q111 2N7002K-AU, Q112 2N7002K-AU, Q113 DMT6007LFGQ, Q114 2N7002K-AU, U18 UCC12040, U19 AP74700QW6-7, U20 VOMA617A, U21 LM5060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

Commit message: mosfet ゲート抵抗追加
Parts:
- added R649, R650, R651: 100, Resistor_SMD:R_0603_1608Metric, symbol Device:R
Connections:
- net PG: now also R649.1, R650.1; no longer Q110.1 (G), Q114.1 (G)
- net ~{DCDC_EN}: now also R651.1; no longer D207.1 (K), Q111.1 (G)
- new net: D207.1 (K), Q111.1 (G), R651.2
- new net: Q110.1 (G), R649.2
- new net: Q114.1 (G), R650.2
Other:
- moved on the sheet: D207
Changed lines of the file:
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@@
   (junction (at 294.64 139.7) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 167.64 177.8) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 228.6 127) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 86.36 215.9) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 165.1 177.8) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 266.7 50.8) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 50.8 88.9) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 165.1 158.75) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 190.5 215.9) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 152.4 215.9) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 167.64 158.75) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 304.8 177.8) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 165.1 158.75) (xy 170.18 158.75))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 226.06 60.96) (xy 231.14 60.96))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 167.64 175.26) (xy 167.64 177.8))
+  (wire (pts (xy 165.1 175.26) (xy 165.1 177.8))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 165.1 158.75) (xy 167.64 158.75))
+  (wire (pts (xy 162.56 158.75) (xy 165.1 158.75))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 171.45 223.52) (xy 171.45 224.79))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 190.5 252.73) (xy 190.5 266.7))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 171.45 223.52) (xy 171.45 226.06))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 76.2 88.9) (xy 76.2 48.26))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 171.45 232.41) (xy 171.45 233.68))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 200.66 161.29) (xy 203.2 161.29))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 322.58 158.75) (xy 325.12 158.75))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 177.8 76.2) (xy 231.14 76.2))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 177.8) (xy 167.64 177.8))
+  (wire (pts (xy 139.7 177.8) (xy 165.1 177.8))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 152.4 158.75) (xy 154.94 158.75))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 330.2 139.7) (xy 317.5 139.7))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 167.64 158.75) (xy 167.64 167.64))
+  (wire (pts (xy 165.1 158.75) (xy 165.1 167.64))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 167.64 177.8) (xy 177.8 177.8))
+  (wire (pts (xy 165.1 177.8) (xy 177.8 177.8))
     (stroke (width 0) (type default))
   )
@@
   )
   (wire (pts (xy 228.6 139.7) (xy 228.6 177.8))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 167.64 158.75) (xy 170.18 158.75))
     (stroke (width 0) (type default))
   )
@@
     )
   )
-  (global_label "~{DCDC_EN}" (shape input) (at 165.1 158.75 180) (fields_autoplaced)
+  (global_label "~{DCDC_EN}" (shape input) (at 152.4 158.75 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 153.5877 158.75 0)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 140.8877 158.75 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
   )
-  (global_label "PG" (shape input) (at 171.45 226.06 270) (fields_autoplaced)
+  (global_label "PG" (shape input) (at 171.45 233.68 270) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 171.45 231.5852 90)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 171.45 239.2052 90)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
-  (global_label "PG" (shape input) (at 332.74 158.75 180) (fields_autoplaced)
+  (global_label "PG" (shape input) (at 322.58 158.75 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 327.2148 158.75 0)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 317.0548 158.75 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     )
   )
+  (symbol (lib_id "Device:R") (at 171.45 228.6 180) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R649" (at 173.99 227.33 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "100" (at 173.99 229.87 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 173.228 228.6 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 171.45 228.6 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "2")
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
+          (reference "R649") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:R") (at 228.6 44.45 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
         (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
           (reference "#FLG021") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Device:R") (at 328.93 158.75 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R650" (at 328.93 152.4 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "100" (at 328.93 154.94 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 328.93 160.528 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 328.93 158.75 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "2")
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
+          (reference "R650") (unit 1)
         )
       )
@@
     )
   )
+  (symbol (lib_id "Device:R") (at 158.75 158.75 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "R651" (at 158.75 152.4 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "100" (at 158.75 154.94 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 158.75 160.528 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 158.75 158.75 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "2")
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
+          (reference "R651") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:C") (at 281.94 130.81 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "ProjectEV:D_SMSZ4690") (at 167.64 171.45 270) (unit 1)
+  (symbol (lib_id "ProjectEV:D_SMSZ4690") (at 165.1 171.45 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "D207" (at 160.02 170.18 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "SMSZ4690" (at 154.94 172.72 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "ProjectEV:D_SOD-123_SMSZ4xxx" (at 167.64 171.45 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "https://goodarksemi.com/docs/datasheets/zener_diodes/SMSZ4xxx.pdf" (at 167.64 171.45 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Reference" "D207" (at 157.48 170.18 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "SMSZ4690" (at 152.4 172.72 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "ProjectEV:D_SOD-123_SMSZ4xxx" (at 165.1 171.45 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://goodarksemi.com/docs/datasheets/zener_diodes/SMSZ4xxx.pdf" (at 165.1 171.45 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: ラベル修正
Connections:
- net DCDC_EN renamed S11_DCDC_EN
- net PG renamed S11_PG
- net ~{DCDC_EN} renamed S11_~{DCDC_EN}
Other:
- moved on the sheet: R644
Changed lines of the file:
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@@
   (junction (at 226.06 60.96) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 241.3 137.16) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 264.16 177.8) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 152.4 266.7) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 238.76 137.16) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 294.64 139.7) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 248.92 139.7) (xy 251.46 139.7))
+  (wire (pts (xy 250.19 139.7) (xy 251.46 139.7))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 238.76 139.7) (xy 238.76 137.16))
+  (wire (pts (xy 238.76 137.16) (xy 241.3 137.16))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 241.3 139.7) (xy 241.3 137.16))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 173.99 234.95) (xy 171.45 234.95))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 190.5 218.44) (xy 190.5 215.9))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 171.45 232.41) (xy 171.45 233.68))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 200.66 161.29) (xy 203.2 161.29))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 177.8) (xy 139.7 101.6))
+  (wire (pts (xy 127 177.8) (xy 127 101.6))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 236.22 137.16) (xy 238.76 137.16))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 139.7 48.26) (xy 139.7 50.8))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 238.76 137.16) (xy 254 137.16))
+  (wire (pts (xy 241.3 137.16) (xy 254 137.16))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 177.8) (xy 165.1 177.8))
+  (wire (pts (xy 127 177.8) (xy 165.1 177.8))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 241.3 139.7) (xy 238.76 139.7))
+  (wire (pts (xy 242.57 139.7) (xy 241.3 139.7))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 101.6) (xy 279.4 101.6))
+  (wire (pts (xy 127 101.6) (xy 279.4 101.6))
     (stroke (width 0) (type default))
   )
@@
   )
   (wire (pts (xy 294.64 127) (xy 304.8 127))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 171.45 234.95) (xy 171.45 232.41))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (global_label "~{DCDC_EN}" (shape output) (at 175.26 76.2 180) (fields_autoplaced)
+  (global_label "S11_~{DCDC_EN}" (shape output) (at 175.26 76.2 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 163.7477 76.2 0)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 159.1516 76.2 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
   )
-  (global_label "~{DCDC_EN}" (shape input) (at 152.4 158.75 180) (fields_autoplaced)
+  (global_label "S11_~{DCDC_EN}" (shape input) (at 152.4 158.75 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 140.8877 158.75 0)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 136.2916 158.75 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
   )
-  (global_label "PG" (shape input) (at 171.45 233.68 270) (fields_autoplaced)
+  (global_label "S11_PG" (shape input) (at 173.99 234.95 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 184.1113 234.95 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+  )
+  (global_label "S11_DCDC_EN" (shape output) (at 205.74 161.29 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 221.8484 161.29 0)
+      (effects (font (size 1.27 1.27)) (justify left) hide)
+    )
+  )
+  (global_label "S11_PG" (shape output) (at 238.76 137.16 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 171.45 239.2052 90)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 228.6387 137.16 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
   )
-  (global_label "DCDC_EN" (shape output) (at 205.74 161.29 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 217.2523 161.29 0)
-      (effects (font (size 1.27 1.27)) (justify left) hide)
-    )
-  )
-  (global_label "PG" (shape output) (at 236.22 137.16 180) (fields_autoplaced)
+  (global_label "S11_DCDC_EN" (shape input) (at 251.46 134.62 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 230.6948 137.16 0)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 235.3516 134.62 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
   )
-  (global_label "DCDC_EN" (shape input) (at 251.46 134.62 180) (fields_autoplaced)
+  (global_label "S11_PG" (shape input) (at 322.58 158.75 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 239.9477 134.62 0)
-      (effects (font (size 1.27 1.27)) (justify right) hide)
-    )
-  )
-  (global_label "PG" (shape input) (at 322.58 158.75 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 317.0548 158.75 0)
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 312.4587 158.75 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
   )
   (symbol (lib_id "Device:C") (at 228.6 133.35 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C358" (at 232.41 132.08 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "0.1u" (at 232.41 134.62 0)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "C358" (at 231.14 132.08 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "0.1u" (at 231.14 134.62 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
     )
   )
-  (symbol (lib_id "Device:R") (at 245.11 139.7 90) (unit 1)
+  (symbol (lib_id "Device:R") (at 246.38 139.7 90) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "R644" (at 245.11 142.24 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "100k" (at 245.11 144.78 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 245.11 141.478 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 245.11 139.7 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Reference" "R644" (at 246.38 142.24 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "100k" (at 246.38 144.78 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 246.38 141.478 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 246.38 139.7 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: アノテーションし直し
Parts:
- renumbered C343 to C345, C344 to C346, C345 to C347, C346 to C348, C347 to C349, C348 to C350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
