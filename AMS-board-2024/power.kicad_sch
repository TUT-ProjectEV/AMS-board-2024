File: AMS-board-2024/power.kicad_sch (KiCad schematic)
At the start: 64 parts, among them Q109 DMT6007LFGQ, Q110 BSS308PE, Q111 2N7002K-AU, Q112 2N7002K-AU, Q113 DMT6007LFGQ, Q114 2N7002K-AU, U18 UCC12040, U19 AP74700QW6-7, U20 VOMA617A, U21 LM5060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

Commit message: ラベル修正とテキスト等の追加
階層シート内の電源シンボルをまとめて階層ラベルとして上層に出し、上層のシートで電源シンボルに接続
Changed lines of the file:
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@@
   (junction (at 228.6 127) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 381 177.8) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 203.2 88.9) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 251.46 139.7) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 279.4 88.9) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 127 266.7) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 114.3 88.9) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 139.7 266.7) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 50.8 215.9) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 381 241.3) (xy 215.9 241.3))
+  (wire (pts (xy 355.6 241.3) (xy 215.9 241.3))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 381 177.8) (xy 393.7 177.8))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 152.4 215.9) (xy 162.56 215.9))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 279.4) (xy 139.7 266.7))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 101.6 38.1) (xy 109.22 38.1))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 279.4 88.9) (xy 304.8 88.9))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 304.8 139.7) (xy 304.8 177.8))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 381 177.8) (xy 381 241.3))
+  (wire (pts (xy 355.6 177.8) (xy 355.6 241.3))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 266.7) (xy 127 266.7))
+  (wire (pts (xy 127 266.7) (xy 152.4 266.7))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 152.4 266.7) (xy 139.7 266.7))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 368.3 127) (xy 393.7 127))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 152.4 279.4) (xy 139.7 279.4))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 228.6 137.16) (xy 228.6 139.7))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 342.9 177.8) (xy 381 177.8))
+  (wire (pts (xy 342.9 177.8) (xy 355.6 177.8))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (hierarchical_label "VBUS2-" (shape output) (at 152.4 279.4 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-  )
   (hierarchical_label "VBUS2+" (shape output) (at 152.4 203.2 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
@@
   )
   (hierarchical_label "PWROUT+" (shape output) (at 304.8 38.1 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-  )
-  (hierarchical_label "PWROUT-" (shape output) (at 304.8 88.9 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-  )
-  (hierarchical_label "VOUT-" (shape output) (at 393.7 177.8 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:PWR_FLAG") (at 304.8 127 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#FLG02" (at 304.8 125.095 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "PWR_FLAG" (at 304.8 121.92 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 304.8 127 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 304.8 127 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
+          (reference "#FLG02") (unit 1)
+        )
+      )

Commit message: 電解コンデンサをセラミックコンデンサに変更
Parts:
- removed C356, C357: 22u, symbol Device:C_Polarized
- added C356, C357: 22u, Capacitor_SMD:C_1206_3216Metric, symbol Device:C
Connections:
- net PWRIN-: now also C356.2, C357.2
- net PWROUT+: now also C357.1
- net at C351.1, C354.1, C359.2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: now also C356.1
Changed lines of the file:
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@@
+    )
+  )
+  (symbol (lib_id "Device:C") (at 203.2 133.35 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C357" (at 207.01 132.08 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "22u" (at 207.01 134.62 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_SMD:C_1206_3216Metric" (at 204.1652 137.16 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 203.2 133.35 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "2")
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
+          (reference "C357") (unit 1)
+        )
+      )
     )
   )
@@
         (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
           (reference "C363") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Device:C") (at 190.5 44.45 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C356" (at 194.31 43.18 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "22u" (at 194.31 45.72 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Capacitor_SMD:C_1206_3216Metric" (at 191.4652 48.26 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 190.5 44.45 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "2")
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
+          (reference "C356") (unit 1)
         )
       )
@@
     )
   )
-  (symbol (lib_id "Device:C_Polarized") (at 203.2 133.35 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C357" (at 207.01 131.191 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "22u" (at 207.01 133.731 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 204.1652 137.16 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 203.2 133.35 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "2")
-    (pin "1")
-    (instances
-      (project "AMS-board-2024"
-        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
-          (reference "C357") (unit 1)
-        )
-      )
-    )
-  )
   (symbol (lib_id "Device:R") (at 152.4 222.25 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "Device:C_Polarized") (at 190.5 44.45 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C356" (at 194.31 42.291 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "22u" (at 194.31 44.831 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 191.4652 48.26 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 190.5 44.45 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "2")
-    (pin "1")
-    (instances
-      (project "AMS-board-2024"
-        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/e5bb215a-09a7-47e9-9b6f-2807241074ff"
-          (reference "C356") (unit 1)
-        )
-      )

Commit message: ヒューズ追加
Parts:
- added F105: 0ABB-5000-TM, ProjectEV:Fuse_0ABB, symbol ProjectEV:Fuse_0ABB-5000-TM
Connections:
- net PWRIN+: now also F105.1; no longer C347.1, C349.1, D203.1 (K), D204.2 (A), D205.2 (A2), Q109.1 (S), Q109.2 (S), Q109.3 (S), U19.3 (EN), U19.6 (ANODE)
- new net: C347.1, C349.1, D203.1 (K), D204.2 (A), D205.2 (A2), F105.2, Q109.1 (S), Q109.2 (S), Q109.3 (S), U19.3 (EN), U19.6 (ANODE)
Other:
- moved on the sheet: C347, C348, C349, C351, C352, C354, C355, C356, C359, C362, C363, C364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
