File: AMS-board-2024/battery-module-monitor-2.kicad_sch (KiCad schematic)
At the start: 154 parts, among them Q14 BSS308PE, Q15 BSS308PE, Q16 BSS308PE, Q17 BSS308PE, Q18 BSS308PE, Q19 BSS308PE, Q20 BSS308PE, Q21 BSS308PE, Q22 BSS308PE, Q23 BSS308PE, Q24 BSS308PE, Q25 BSS308PE, Q26 NSV1C201MZ4, U2 LTC6811-1

Commit message: アノテーションし直し、
Parts:
- R120: renamed from R124; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- R128: renamed from R132; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- renumbered C40 to C38, C41 to C39, C42 to C40, C43 to C41, C44 to C42, C45 to C43, C46 to C44, C47 to C45, C48 to C46, C49 to C47, C50 to C48, C51 to C49, C52 to C50, C53 to C51, C54 to C52, C55 to C53, C56 to C54, C57 to C55, C58 to C56, C59 to C57, C60 to C58, C61 to C59, C62 to C60, C63 to C61, C64 to C62, C65 to C63, C67 to C64, C69 to C65, C70 to C66, C71 to C67, C72 to C68, C73 to C69, C74 to C70, C75 to C71, C76 to C72, C77 to C73, C78 to C74, D24 to D20, D25 to D21, D26 to D22, D27 to D23, D28 to D24, D29 to D25, D30 to D26, D31 to D27, D32 to D28, D33 to D29, D34 to D30, D35 to D31, D36 to D32, D37 to D33, D38 to D34, D41 to D35, D42 to D36, D43 to D37, D44 to D38, R104 to R100, R105 to R101, R106 to R102, R107 to R103, R108 to R104, R109 to R105, R110 to R106, R111 to R107, R112 to R108, R113 to R109, R114 to R110, R115 to R111, R116 to R112, R117 to R113, R118 to R114, R119 to R115, R120 to R116, R121 to R117, R122 to R118, R123 to R119, R125 to R121, R126 to R122, R127 to R123, R128 to R124, R129 to R125, R130 to R126, R131 to R127, R133 to R129, R134 to R130, R135 to R131, R136 to R132, R137 to R133, R138 to R134, R139 to R135, R142 to R136, R143 to R137, R144 to R138, R75 to R71, R76 to R72, R77 to R73, R78 to R74, R79 to R75, R80 to R76, R81 to R77, R82 to R78, R83 to R79, R84 to R80, R85 to R81, R86 to R82, R87 to R83, R88 to R84, R89 to R85, R90 to R86, R91 to R87, R92 to R88, R93 to R89, R94 to R90, R95 to R91, R96 to R92, R97 to R93, R98 to R94, R99 to R95, R100 to R96, R101 to R97, R102 to R98, R103 to R99
