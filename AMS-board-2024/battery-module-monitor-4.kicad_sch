File: AMS-board-2024/battery-module-monitor-4.kicad_sch (KiCad schematic)
At the start: 164 parts, among them Q40 BSS308PE, Q41 BSS308PE, Q42 BSS308PE, Q43 BSS308PE, Q44 BSS308PE, Q45 BSS308PE, Q46 BSS308PE, Q47 BSS308PE, Q48 BSS308PE, Q49 BSS308PE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

Commit message: ERC実行、修正
ラベル修正、未配線部分修正、PWR_FLAG追加
Connections:
- net GND1 is gone; now on net GND4: C118.2, C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2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
- net GND4: now reaches U4.36 (SWTEN)
- net VREG renamed VREG4
Changed lines of the file:
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@@
   (junction (at 114.3 293.37) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 101.6 381) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 165.1 245.11) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 342.9 127) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 292.1 165.1) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 165.1 269.24) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 101.6 381) (xy 101.6 383.54))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 365.76 266.7) (xy 368.3 266.7))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 96.52 381) (xy 101.6 381))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 441.96 304.8) (xy 444.5 304.8))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 304.8 223.52) (xy 307.34 223.52))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 320.04 243.84) (xy 330.2 243.84))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 101.6 378.46) (xy 101.6 379.73))
+  (wire (pts (xy 101.6 378.46) (xy 101.6 381))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left))
   )
-  (hierarchical_label "VREG" (shape output) (at 419.1 223.52 0) (fields_autoplaced)
+  (hierarchical_label "VREG4" (shape output) (at 419.1 223.52 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (hierarchical_label "GND" (shape output) (at 419.1 228.6 0) (fields_autoplaced)
+  (hierarchical_label "GND4" (shape output) (at 419.1 228.6 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
@@
     )
   )
-  (symbol (lib_id "ProjectEV:GND4") (at 101.6 379.73 0) (unit 1)
+  (symbol (lib_id "ProjectEV:GND4") (at 101.6 383.54 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR0145" (at 101.6 386.08 0)
+    (property "Reference" "#PWR0145" (at 101.6 389.89 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "GND4" (at 101.6 384.81 0)
+    (property "Value" "GND4" (at 101.6 388.62 0)
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 101.6 379.73 0)
+    (property "Footprint" "" (at 101.6 383.54 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "" (at 101.6 379.73 0)
+    (property "Datasheet" "" (at 101.6 383.54 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
+  (symbol (lib_id "ProjectEV:GND4") (at 307.34 223.52 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR0436" (at 313.69 223.52 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND4" (at 311.15 223.52 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "" (at 307.34 223.52 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 307.34 223.52 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/a39a1448-0121-4ed9-a3f7-e78aeb0267a9"
+          (reference "#PWR0436") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "ProjectEV:D_BAT46W-7-F") (at 368.3 336.55 270) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
+  (symbol (lib_id "power:PWR_FLAG") (at 292.1 165.1 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#FLG05" (at 292.1 163.195 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "PWR_FLAG" (at 292.1 160.02 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 292.1 165.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 292.1 165.1 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/a39a1448-0121-4ed9-a3f7-e78aeb0267a9"
+          (reference "#FLG05") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Device:R") (at 393.7 82.55 180) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:PWR_FLAG") (at 96.52 381 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#FLG013" (at 96.52 379.095 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "PWR_FLAG" (at 96.52 375.92 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 96.52 381 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 96.52 381 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "AMS-board-2024"
+        (path "/3a719eb3-09ce-4343-8f6e-20cc0aaf5261/a39a1448-0121-4ed9-a3f7-e78aeb0267a9"
+          (reference "#FLG013") (unit 1)
+        )
+      )

Commit message: ラベル修正
Connections:
- net VREG4 renamed VREG
Changed lines of the file:
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@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "VREG4" (at 365.76 317.5 0) (fields_autoplaced)
+  (label "S5_VREG" (at 365.76 317.5 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "VREG4" (at 365.76 266.7 0) (fields_autoplaced)
+  (label "S5_VREG" (at 342.9 215.9 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "VREG4" (at 342.9 215.9 0) (fields_autoplaced)
+  (label "S5_VREG" (at 378.46 292.1 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "VREG4" (at 378.46 241.3 0) (fields_autoplaced)
+  (label "S5_VREG" (at 378.46 342.9 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "VREG4" (at 378.46 292.1 0) (fields_autoplaced)
+  (label "S5_VREG" (at 378.46 241.3 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "VREG4" (at 378.46 342.9 0) (fields_autoplaced)
+  (label "S5_VREG" (at 365.76 266.7 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left))
   )
-  (hierarchical_label "VREG4" (shape output) (at 419.1 223.52 0) (fields_autoplaced)
+  (hierarchical_label "VREG" (shape output) (at 419.1 223.52 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )

Commit message: アノテーションし直し
Parts:
- renumbered L20 to L21

Commit message: ラベル修正とテキスト等の追加
階層シート内の電源シンボルをまとめて階層ラベルとして上層に出し、上層のシートで電源シンボルに接続
Connections:
- net GND4 renamed GND

Commit message: LTC6811のシンボルを更新
Parts:
- U4: footprint ProjectEV:SSOP-48_5.3x12.8mm_P0.5mm_LTC6811 -> ProjectEV:Package_SSOP-48_5.3x12.8mm_P0.5mm_LTC6811
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "ProjectEV:SSOP-48_5.3x12.8mm_P0.5mm_LTC6811" (at 290.83 213.36 0)
+    (property "Footprint" "ProjectEV:Package_SSOP-48_5.3x12.8mm_P0.5mm_LTC6811" (at 290.83 213.36 0)
       (effects (font (size 1.27 1.27)) hide)
     )

Commit message: チップ抵抗、チップコンデンササイズ修正
Parts:
- C130, C131, C132, C133, C134, C135, C136, C137, C138, C139, C140, C141, C142, C144, C145, C146, C147, C148, C149, C150, C151, C152, C153, C155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: footprint Capacitor_SMD:C_0603_1608Metric -> Capacitor_SMD:C_0402_1005Metric
- R243, R244, R245, R246, R247, R248, R249, R250, R251, R252, R253, R254, R255, R256, R257, R258, R259, R260, R261, R262, R263, R264, R265, R266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: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0402_1005Metric

Commit message: 温度センサ用コネクタ変更、大まかな位置決定
Parts:
- removed C144, C146: 0.1u, Capacitor_SMD:C_0402_1005Metric, symbol Device:C
- removed D85, D86, D91, D92: BAT46W-7-F, ProjectEV:D_SOD-123_BAT46W-7-F, symbol ProjectEV:D_BAT46W-7-F
- removed R284, R285: 100, Resistor_SMD:R_0402_1005Metric, symbol Device:R
- removed R289, R290: 10k, Resistor_SMD:R_0402_1005Metric, symbol Device:R
Connections:
- net VREF_3V: no longer names the net of C145.2, R286.1, R287.1, R288.1, U4.34 (VREF2)
- net VREG: no longer names the net of C148.1, D83.1 (K), D87.1 (K), D89.1 (K), Q52.3 (E), R270.1, U4.37 (VREG), U4.40 (ISOMD)
- no-connect marks 2 -> 4
